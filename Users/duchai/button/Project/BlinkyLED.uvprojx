# Keil uVision project BlinkyLED.uvprojx, settings and files
target BlynkLed (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlinkyLED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: .\inc;..\STM32F4xx_StdPeriph_Driver;..\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main_source
    ./src/: delay.c main.c
  group include
    ./inc/: delay.h
  group STD_lib
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.6.2
